require maxytec-stb-kodi.inc

COMPATIBLE_MACHINE = "^(multibox)$"
