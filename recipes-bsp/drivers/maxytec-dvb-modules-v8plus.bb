KV = "4.4.35"
SRCDATE = "20190401"

require maxytec-dvb-modules.inc

SRC_URI[md5sum] = "1c44b8957c6acdad8eb7d945037cee6c"
SRC_URI[sha256sum] = "64175f5e97cab97231fc827f18799eba555a2cb51ea7a709fc39b9c851c0a9b9"

COMPATIBLE_MACHINE = "v8plus"
